FILESEXTRAPATHS_prepend_poky := "${THISDIR}/files:"
SPLASH_IMAGES = "file://my-custom-psplash.png;outsuffix=default"

